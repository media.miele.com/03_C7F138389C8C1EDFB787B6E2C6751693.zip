Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: c5ace4dc-0c3d-43db-8b82-f21106013f09, NumberOfSaves: 1]
File name: 0001
Time: 2025-01-20T08:37:55+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12679150_KZ_DAH4970_OBSW:28H4970B_KZ_12679150_DAH4970_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_CLST, z_Miele_Design_OBSW, <Unnamed>, z_Miele_Design_Glass, z_Miele_Design_Steel_Chrom, z_Miele_Connection_Connection_Modul
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 898 mm; Height: 420 mm; Depth: 381 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 28H4970B_KZ_12679150_DAH4970_OBSW; sets with these values: 2
